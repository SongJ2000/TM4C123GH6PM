# Keil uVision project TM4C12x_Demo.uvprojx, settings and files
target Source (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: TM4C12x_Demo +hex
  c flags: Optim=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: PART_TM4C123GH6PM,TARGET_IS_BLIZZARD_RA1,TM4C123GH6PM
  c include: ..\User;..\Core;..\System;..\Library;..\Hardware
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group User
    ../User/: main.c
  group System
    ../System/: system_TM4C123.c system.c
    ../Library/utils/: uartstdio.c
  group Hardware
    ../Hardware/UART/: myUART.c
    ../Hardware/PWM/: myPWM.c
    ../Hardware/IIC/: myIIC.c
    ../Hardware/SPI/: mySPI.c
    ../Hardware/OLED/: oled.c
    ../Hardware/TFT/: TFT18.c TFT18_Font.c
    ../Hardware/ADC/: ADC.c
    ../Hardware/KEY/: KEY.c
    ../Hardware/CHIP/DAC081S101/: DAC081S101.c
  group Library
    ../Library/driverlib/: adc.c aes.c can.c comp.c cpu.c crc.c des.c eeprom.c emac.c epi.c flash.c fpu.c gpio.c hibernate.c i2c.c interrupt.c lcd.c mpu.c onewire.c pwm.c qei.c shamd5.c ssi.c sw_crc.c sysctl.c sysexc.c systick.c timer.c uart.c udma.c usb.c watchdog.c
  group Core
    ../Core/: startup_TM4C123.s
